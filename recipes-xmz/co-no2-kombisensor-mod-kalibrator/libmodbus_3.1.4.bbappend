# Use Version 3.1.4 
# See: meta-openembedded/meta-oe/recipes-extended/libmodbus/libmodbus_3.1.4.bb
DEFAULT_PREFERENCE = "1"
